Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Ever Alu - Coffee table D90 - ver4.ifc
Time: 2025-11-26T17:24:22
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (3)
Name
 | Ever Alu - Coffee table D90_0 - ObjectType: SketchupGroup
 | Ever Alu - Coffee table D90_1 - ObjectType: SketchupGroup
 | Ever Alu - Coffee table D90_2 - ObjectType: SketchupGroup
